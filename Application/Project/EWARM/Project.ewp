# IAR project Project.ewp, settings and files
configuration IMXRT1060-EVK (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SERIAL_PORT_TYPE_UART=1; NDEBUG; CPU_MIMXRT1062DVL6B; SDK_I2C_BASED_COMPONENT_USED=1; EW_USE_OPERATING_SYSTEM=1; EW_SURFACE_ROTATION=0; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ../../Source; ..\..\..\ThirdParty\MCUXpressoSDK\CMSIS\Core\Include; ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT1062\drivers; ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT1062; ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT1062/utilities; ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT1062/utilities/str; ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT1062/utilities/debug_console; ..\..\..\ThirdParty\MCUXpressoSDK\components\ft5406_rt; ..\..\..\ThirdParty\MCUXpressoSDK\components\serial_manager; ..\..\..\ThirdParty\MCUXpressoSDK\components\uart; ..\..\..\PlatformPackage\RTE; ..\..\..\TargetSpecific; ..\..\GeneratedCode; ..\..\..\TargetSpecific\Drivers; ..\..\GeneratedCode\EmWiGfxInclude; ..\..\..\ThirdParty\MCUXpressoSDK\rtos\freertos\freertos-kernel\include; ..\..\..\ThirdParty\MCUXpressoSDK\rtos\freertos\freertos-kernel\include\private; ..\..\..\ThirdParty\MCUXpressoSDK\rtos\freertos\freertos-kernel\portable\IAR\ARM_CM4F; ..\..\..\ThirdParty\MCUXpressoSDK\components\gt911
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..\..\Source
  OBJCOPY.OOCOutputFile: EmbeddedWizard-IMXRT1060-EVK.hex
  ILINK.IlinkOutputFile: EmbeddedWizard-IMXRT1060-EVK.elf
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../GeneratedCode/: ewfiles.ipcf
  group Application
    ../../Source/: DeviceDriver.c ewmain.c main.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/: system_MIMXRT1062.c
  group Application/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_os.c ew_bsp_system.c ew_bsp_touch.c
  group Application/TargetSpecific/Drivers
    ../../../TargetSpecific/Drivers/: board.c clock_config.c dcd.c pin_mux.c
  group Drivers
    ../../../ThirdParty/MCUXpressoSDK/components/uart/: fsl_adapter_lpuart.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/utilities/: fsl_assert.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/drivers/: fsl_clock.c fsl_common.c fsl_elcdif.c fsl_gpio.c fsl_lpi2c.c fsl_lpuart.c fsl_pxp.c fsl_snvs_hp.c
    ../../../ThirdParty/MCUXpressoSDK/components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_port_uart.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c
    ../../../ThirdParty/MCUXpressoSDK/components/ft5406_rt/: fsl_ft5406_rt.c
    ../../../ThirdParty/MCUXpressoSDK/components/gt911/: fsl_gt911.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/utilities/str/: fsl_str.c
  group Drivers/IXP
    ../../../ThirdParty/MCUXpressoSDK/boards/evkbmimxrt1060/xip/: evkbmimxrt1060_flexspi_nor_config.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c
  group EmbeddedWizard/GeneratedCode
    ../../GeneratedCode/: _WasherBgDelicates.h _WasherBgDrain.h _WasherBgEasyCare.h _WasherBgEco.h _WasherBgHot.h _WasherBgSpin.h _WasherBgSportswear.h _WasherBgWool.h _WasherDescrFont.h _WasherListFontL.h _WasherListFontM.h _WasherListFontS.h _WasherListFontXL.h _WasherShadow.h Application.c Core.c Effects.c Graphics.c Resources.c Views.c Washer.c
  group EmbeddedWizard/RGB565
    ../../../PlatformPackage/RGB565/: ewextgfx.c libewgfx-m7-iar.a
  group EmbeddedWizard/RTE
    ../../../PlatformPackage/RTE/: ewextrte.c libewrte-m7-iar.a
  group FreeRTOS
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos-kernel/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s
