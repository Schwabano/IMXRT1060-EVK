# Keil uVision project Project.uvprojx, settings and files
target IMXRT1060-EVK (6190000::V6.19::ARMCLANG)
  device: MIMXRT1062CVL5A NXP
  pack: NXP.MIMXRT1062_DFP.15.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: EmbeddedWizard-IMXRT1060-EVK.elf +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=3
  c define: NDEBUG, SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SERIAL_PORT_TYPE_UART=1, CPU_MIMXRT1062DVL6B, SDK_I2C_BASED_COMPONENT_USED=1, EW_USE_OPERATING_SYSTEM=1
  c include: ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT1062;..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT1062\drivers;..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT1062\utilities;..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT1062\utilities\str;..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT1062\utilities\debug_console;..\..\..\ThirdParty\MCUXpressoSDK\components\serial_manager;..\..\..\ThirdParty\MCUXpressoSDK\components\uart;..\..\..\ThirdParty\MCUXpressoSDK\components\ft5406_rt;..\..\..\ThirdParty\MCUXpressoSDK\components\gt911;..\..\..\ThirdParty\MCUXpressoSDK\CMSIS\Core\Include;..\..\..\ThirdParty\MCUXpressoSDK\rtos\freertos\freertos-kernel\include;..\..\..\ThirdParty\MCUXpressoSDK\rtos\freertos\freertos-kernel\portable\GCC\ARM_CM4F;..\..\..\ThirdParty\MCUXpressoSDK\rtos\freertos\freertos-kernel\include\private;..\..\..\TargetSpecific;..\..\..\TargetSpecific\Drivers;..\..\GeneratedCode;..\..\Source
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove
--keep=*(.boot_hdr.ivt)
--keep=*(.boot_hdr.boot_data)
--keep=*(.boot_hdr.dcd_data)
--keep=*(.boot_hdr.conf)
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group board
    ../../../TargetSpecific/Drivers/: board.c clock_config.c dcd.c pin_mux.c
  group drivers
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/drivers/: fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_snvs_hp.c
    ../../../ThirdParty/MCUXpressoSDK/components/ft5406_rt/: fsl_ft5406_rt.c
    ../../../ThirdParty/MCUXpressoSDK/components/gt911/: fsl_gt911.c
  group startup
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/: system_MIMXRT1062.c system_MIMXRT1062.h
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/arm/: startup_MIMXRT1062.s
  group utilities
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/utilities/: fsl_assert.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c
    ../../../ThirdParty/MCUXpressoSDK/components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_port_uart.c
    ../../../ThirdParty/MCUXpressoSDK/components/uart/: fsl_adapter_lpuart.c
  group xip
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../ThirdParty/MCUXpressoSDK/boards/evkbmimxrt1060/xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
  group EmWi/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_console.c ew_bsp_os.c ew_bsp_system.c ew_bsp_touch.c ew_bsp_graphics.c
  group EmWi/Application
    ../../Source/: main.c DeviceDriver.c ewmain.c
  group FreeRTOS
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos-kernel/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c
software components: Graphics:Embedded Wizard:New Project... 1.0.0
